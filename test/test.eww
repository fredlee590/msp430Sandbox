<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\..\blink\blink.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\p2inTest\p2inTest.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\test.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\uartTest\uartTest.ewp</path>
  </project>
  <batchBuild/>
</workspace>


