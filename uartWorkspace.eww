<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\uartPythonTest\uartPythonTest.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\uartTest\uartTest.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\uartWithFt232RL\uartWithFt232RL.ewp</path>
  </project>
  <batchBuild/>
</workspace>


