<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\memUartTest\memUartTest.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\viewMemTest\viewMemTest.ewp</path>
  </project>
  <batchBuild/>
</workspace>


